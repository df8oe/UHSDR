<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>conv_dir</value></param>
<param><key>choices</key><value>[0,1]</value></param>
<param><key>value</key><value>1</value></param>
<param><key>grid_pos</key><value> (1, 0, 1, 1)</value></param>
<param><key>label</key><value></value></param>
<param><key>labels</key><value>['UP','DOWN']</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>type</key><value>drop_down</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dmod_mode</value></param>
<param><key>value</key><value>dmod_mode_ui</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>dmod_mode_ui</value></param>
<param><key>choices</key><value>[0,1]</value></param>
<param><key>value</key><value>1</value></param>
<param><key>grid_pos</key><value> (2, 0, 1, 1)</value></param>
<param><key>label</key><value></value></param>
<param><key>labels</key><value>['USB','LSB']</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>type</key><value>drop_down</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>variable_taps</value></param>
<param><key>value</key><value>145</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_0</value></param>
<param><key>bits_per_sample</key><value>16</value></param>
<param><key>file</key><value>/tmp/mchfaudio.wav</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>mchf_demod</key>
<param><key>id</key><value>mchf_demod_0</value></param>
<param><key>dmod_mode</key><value>dmod_mode</value></param>
</block>
<block>
<key>mchf_freq_conv</key>
<param><key>id</key><value>mchf_freq_conv_0</value></param>
<param><key>conv_dir</key><value>conv_dir</value></param>
<param><key>freq_offset</key><value>6000</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>mchf_iq_hilbert</key>
<param><key>id</key><value>mchf_iq_hilbert_0</value></param>
<param><key>num_taps</key><value>variable_taps</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>mchf_rf_frontend</key>
<param><key>id</key><value>mchf_rf_frontend_0</value></param>
<param><key>mchf_rf_fe_samp_rate</key><value>samp_rate</value></param>
<param><key>mchf_rf_fe_vfo</key><value>0</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>grid_pos</key><value> (2, 1, 1, 1)</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>title</key><value>Audio</value></param>
<param><key>type</key><value>float</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>grid_pos</key><value> (1, 1, 1, 1)</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>title</key><value>IQ Audio Baseband</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_wavfile_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mchf_demod_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mchf_freq_conv_0</source_block_id><sink_block_id>mchf_iq_hilbert_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mchf_freq_conv_0</source_block_id><sink_block_id>wxgui_fftsink2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mchf_iq_hilbert_0</source_block_id><sink_block_id>mchf_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mchf_rf_frontend_0</source_block_id><sink_block_id>mchf_freq_conv_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mchf_rf_frontend_0</source_block_id><sink_block_id>mchf_freq_conv_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
</flow_graph>
